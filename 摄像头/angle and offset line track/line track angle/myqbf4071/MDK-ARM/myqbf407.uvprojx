# Keil uVision project myqbf407.uvprojx, settings and files
target myqbf407 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: myqbf407 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../HARDWARE;../HARDWARE/MOTOR;../HARDWARE/JY62;../HARDWARE/myitqb;../HARDWARE/encoder;../HARDWARE/PID;../SYSTEM/system;../HARDWARE/GO;../HARDWARE/tjc;../HARDWARE/fprintf;../HARDWARE/middleware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group New Group
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/: head.h
    ../HARDWARE/JY62/: jy62.c jy62.h
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/GO/: go.c go.h
    ../SYSTEM/system/: system.c system.h
    ../HARDWARE/myitqb/: myitqb.c myitqb.h
    ../HARDWARE/tjc/: tjc_usart_hmi.h tjc_usart_hmi.c
    ../HARDWARE/fprintf/: fprintf.c fprintf.h
    ../HARDWARE/middleware/: ringbuffer.c ringbuffer.h serial_protocol.c serial_protocol.h protocol_test.c protocol_test.h
software components: CMSIS:CORE 4.3.0
